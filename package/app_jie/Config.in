## package/app_jie/Config.in
```kconfig
config BR2_PACKAGE_APP_JIE
    bool "app_jie"
    help
      This is a demo to add local app.
```
